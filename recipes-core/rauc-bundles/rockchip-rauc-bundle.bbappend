RAUC_SLOT_rootfs = "cm3588nas-image"
