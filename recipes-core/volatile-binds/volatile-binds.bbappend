VOLATILE_BINDS:remove = "${localstatedir}/volatile/lib ${localstatedir}/lib\n"
